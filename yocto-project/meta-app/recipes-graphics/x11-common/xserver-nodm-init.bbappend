PR := "${PR}.1"

INITSCRIPT_PARAMS = "start 9 5 3 2 . stop 91 0 1 6 ."
