# This is disabled for now since for some reason StartupGUI gets
# started okay, but next application needs to be started twice to 
# it's to show up on screen.
#FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:${THISDIR}/files:"
#PR := "${PR}.3"
