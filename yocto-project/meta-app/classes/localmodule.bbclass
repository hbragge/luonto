inherit module externalsrc

EXTERNALSRC = "${COREBASE}/../drivers/${PN}"
EXTERNALSRC_BUILD = "${EXTERNALSRC}"
