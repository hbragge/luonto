inherit base externalsrc

EXTERNALSRC = "${COREBASE}/../apps/${PN}"
EXTERNALSRC_BUILD = "${EXTERNALSRC}"
